// =====================================================================
//  one_digit_v2 — учебный скетч: показать ОДНУ цифру на индикаторе E20362
//
//  Задайте цифру в константе DIGIT, залейте — она загорится и будет
//  гореть постоянно. Никакой динамической индикации, режимов и команд:
//  только то, что нужно, чтобы понять, как зажигается цифра.
//
//  Подключение — то же, что у led_clock_v2 (docs/03-hardware.md):
//  сегменты через резисторы 470 Ом, аноды цифр — напрямую.
//
//  Плата:      DOIT ESP32 DEVKIT V1
//  Библиотеки: —
//  Пояснения:  docs/05-one-digit.md
// =====================================================================

// ---------------------------------------------------------------------
// 1. ЧТО ПОКАЗАТЬ — меняйте эти две строки и заливайте заново
// ---------------------------------------------------------------------
const int DIGIT    = 7;   // какую цифру показать: 0..9
const int POSITION = 1;   // где: 1 — левая цифра, 2 — правая

// ---------------------------------------------------------------------
// 2. К КАКИМ ПИНАМ ESP32 ЧТО ПОДКЛЮЧЕНО
// ---------------------------------------------------------------------
//
//        A
//      F   B        Цифра состоит из 7 полосок — сегментов A..G.
//        G          Каждый сегмент — это светодиод.
//      E   C
//        D
//
// Сегменты (через резистор 470 Ом).
//
// Числа — это номера пинов ESP32 (GPIO), к которым подключён провод сегмента.
// Пример первой строки: GPIO21 = вывод «D21» на плате → резистор → ножка 3
// индикатора → сегмент A. Команда digitalWrite(21, LOW) зажигает верхнюю полоску.
//
// На плате DOIT DevKit V1 надпись = «D» + номер GPIO (21 → D21).
// Разводка v2: верхний ряд ножек индикатора (10…6) — верхний ряд платы,
// нижний ряд (1…5) — нижний ряд платы.
//
// Порядок важен: позиция в массиве = сегмент ([0] — A, [1] — B, ... [6] — G),
// столбцы таблицы DIGIT_SEGMENTS ниже идут в том же порядке.
// Переставили провод на другой пин — поменяйте здесь только число.
const int SEGMENT_PINS[7] = {
  //GPIO   сегмент              надпись на плате → ножка индикатора
  21,   // A — верх             D21 → ножка 3  (нижний ряд платы)
  33,   // B — верх справа      D33 → ножка 9  (верхний ряд платы)
  25,   // C — низ справа       D25 → ножка 8  (верхний ряд платы)
  27,   // D — низ              D27 → ножка 6  (верхний ряд платы)
  26,   // E — низ слева        D26 → ножка 7  (верхний ряд платы)
  22,   // F — верх слева       D22 → ножка 4  (нижний ряд платы)
  18,   // G — середина         D18 → ножка 1  (нижний ряд платы)
};
const char* SEGMENT_NAMES[7] = {"A", "B", "C", "D", "E", "F", "G"};

// Общие аноды — «плюс» для всей цифры сразу (без резистора).
// Тоже номера GPIO: 32 = вывод «D32» на плате, 23 = «D23».
const int LEFT_DIGIT_PIN  = 32;  // D32 → ножка 10 — левая цифра  (верхний ряд платы)
const int RIGHT_DIGIT_PIN = 23;  // D23 → ножка 5  — правая цифра (нижний ряд платы)

// ---------------------------------------------------------------------
// 3. КАКИЕ СЕГМЕНТЫ ГОРЯТ У КАЖДОЙ ЦИФРЫ (1 — горит, 0 — нет)
// ---------------------------------------------------------------------
const int DIGIT_SEGMENTS[10][7] = {
  //A  B  C  D  E  F  G
  { 1, 1, 1, 1, 1, 1, 0 },  // 0
  { 0, 1, 1, 0, 0, 0, 0 },  // 1
  { 1, 1, 0, 1, 1, 0, 1 },  // 2
  { 1, 1, 1, 1, 0, 0, 1 },  // 3
  { 0, 1, 1, 0, 0, 1, 1 },  // 4
  { 1, 0, 1, 1, 0, 1, 1 },  // 5
  { 1, 0, 1, 1, 1, 1, 1 },  // 6
  { 1, 1, 1, 0, 0, 0, 0 },  // 7
  { 1, 1, 1, 1, 1, 1, 1 },  // 8
  { 1, 1, 1, 1, 0, 1, 1 },  // 9
};

// ---------------------------------------------------------------------
// 4. КАК ЗАЖЕЧЬ СЕГМЕНТ
// ---------------------------------------------------------------------
// Ток течёт ОТ плюса К минусу:
//
//   пин анода (HIGH = 3,3 В) → светодиод сегмента → резистор → пин сегмента (LOW = 0 В)
//
// Поэтому:
//   анод цифры    HIGH — цифра «включена»,  LOW  — выключена;
//   пин сегмента  LOW  — сегмент горит,      HIGH — не горит
//                 (с обеих сторон 3,3 В — разницы нет, ток не течёт).

void setup() {
  Serial.begin(115200);
  delay(200);
  Serial.printf("\n=== one_digit_v2: показываю %d на %s цифре ===\n",
                DIGIT, POSITION == 1 ? "левой" : "правой");

  // Шаг 1. Все сегменты — выходы и выключены (HIGH)
  for (int i = 0; i < 7; i++) {
    pinMode(SEGMENT_PINS[i], OUTPUT);
    digitalWrite(SEGMENT_PINS[i], HIGH);
  }

  // Шаг 2. Обе цифры — выходы и выключены (LOW)
  pinMode(LEFT_DIGIT_PIN, OUTPUT);
  pinMode(RIGHT_DIGIT_PIN, OUTPUT);
  digitalWrite(LEFT_DIGIT_PIN, LOW);
  digitalWrite(RIGHT_DIGIT_PIN, LOW);

  // Шаг 3. Включаем нужные сегменты по таблице
  for (int i = 0; i < 7; i++) {
    if (DIGIT_SEGMENTS[DIGIT][i] == 1) {
      digitalWrite(SEGMENT_PINS[i], LOW);   // этот сегмент горит
      Serial.printf("  сегмент %s: горит   (GPIO %d = LOW)\n", SEGMENT_NAMES[i], SEGMENT_PINS[i]);
    } else {
      Serial.printf("  сегмент %s: —       (GPIO %d = HIGH)\n", SEGMENT_NAMES[i], SEGMENT_PINS[i]);
    }
  }

  // Шаг 4. Подаём «плюс» на выбранную цифру — она загорается
  int digitPin = (POSITION == 1) ? LEFT_DIGIT_PIN : RIGHT_DIGIT_PIN;
  digitalWrite(digitPin, HIGH);
  Serial.printf("  анод: GPIO %d = HIGH — цифра включена\n", digitPin);
}

void loop() {
  // Ничего не делаем: пины остаются в том состоянии, в каком их оставил setup(),
  // и цифра горит постоянно.
}
