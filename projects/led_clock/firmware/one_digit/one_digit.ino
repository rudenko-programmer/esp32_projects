// =====================================================================
//  one_digit — учебный скетч: показать ОДНУ цифру на индикаторе E20362
//
//  Задайте цифру в константе DIGIT, залейте — она загорится и будет
//  гореть постоянно. Никакой динамической индикации, режимов и команд:
//  только то, что нужно, чтобы понять, как зажигается цифра.
//
//  Подключение — то же, что у led_clock (docs/03-hardware.md):
//  сегменты через резисторы 470 Ом, аноды цифр — напрямую.
//
//  Плата:      DOIT ESP32 DEVKIT V1
//  Библиотеки: —
//  Пояснения:  docs/05-one-digit.md
// =====================================================================

// ---------------------------------------------------------------------
// 1. ЧТО ПОКАЗАТЬ — меняйте эти две строки и заливайте заново
// ---------------------------------------------------------------------
const int DIGIT    = 7;   // какую цифру показать: 0..9
const int POSITION = 1;   // где: 1 — левая цифра, 2 — правая

// ---------------------------------------------------------------------
// 2. К КАКИМ ПИНАМ ESP32 ЧТО ПОДКЛЮЧЕНО
// ---------------------------------------------------------------------
//
//        A
//      F   B        Цифра состоит из 7 полосок — сегментов A..G.
//        G          Каждый сегмент — это светодиод.
//      E   C
//        D
//
// Сегменты (через резистор 470 Ом).
//
// Числа — это номера пинов ESP32 (GPIO), к которым подключён провод сегмента.
// Пример первой строки: GPIO13 = вывод «D13» на плате → резистор → ножка 3
// индикатора → сегмент A. Команда digitalWrite(13, LOW) зажигает верхнюю полоску.
//
// На плате DOIT DevKit V1 надпись обычно = «D» + номер GPIO (13 → D13),
// кроме GPIO16 и GPIO17 — они подписаны RX2 и TX2.
//
// Порядок важен: позиция в массиве = сегмент ([0] — A, [1] — B, ... [6] — G),
// столбцы таблицы DIGIT_SEGMENTS ниже идут в том же порядке.
// Переставили провод на другой пин — поменяйте здесь только число.
const int SEGMENT_PINS[7] = {
  //GPIO   сегмент              надпись на плате → ножка индикатора
  13,   // A — верх             D13 → ножка 3
  14,   // B — верх справа      D14 → ножка 9
  16,   // C — низ справа       RX2 → ножка 8
  17,   // D — низ              TX2 → ножка 6
  18,   // E — низ слева        D18 → ножка 7
  19,   // F — верх слева       D19 → ножка 4
  21,   // G — середина         D21 → ножка 1
};
const char* SEGMENT_NAMES[7] = {"A", "B", "C", "D", "E", "F", "G"};

// Общие аноды — «плюс» для всей цифры сразу (без резистора).
// Тоже номера GPIO: 23 = вывод «D23» на плате, 25 = «D25».
const int LEFT_DIGIT_PIN  = 23;  // D23 → ножка 10 — левая цифра
const int RIGHT_DIGIT_PIN = 25;  // D25 → ножка 5  — правая цифра

// ---------------------------------------------------------------------
// 3. КАКИЕ СЕГМЕНТЫ ГОРЯТ У КАЖДОЙ ЦИФРЫ (1 — горит, 0 — нет)
// ---------------------------------------------------------------------
const int DIGIT_SEGMENTS[10][7] = {
  //A  B  C  D  E  F  G
  { 1, 1, 1, 1, 1, 1, 0 },  // 0
  { 0, 1, 1, 0, 0, 0, 0 },  // 1
  { 1, 1, 0, 1, 1, 0, 1 },  // 2
  { 1, 1, 1, 1, 0, 0, 1 },  // 3
  { 0, 1, 1, 0, 0, 1, 1 },  // 4
  { 1, 0, 1, 1, 0, 1, 1 },  // 5
  { 1, 0, 1, 1, 1, 1, 1 },  // 6
  { 1, 1, 1, 0, 0, 0, 0 },  // 7
  { 1, 1, 1, 1, 1, 1, 1 },  // 8
  { 1, 1, 1, 1, 0, 1, 1 },  // 9
};

// ---------------------------------------------------------------------
// 4. КАК ЗАЖЕЧЬ СЕГМЕНТ
// ---------------------------------------------------------------------
// Ток течёт ОТ плюса К минусу:
//
//   пин анода (HIGH = 3,3 В) → светодиод сегмента → резистор → пин сегмента (LOW = 0 В)
//
// Поэтому:
//   анод цифры    HIGH — цифра «включена»,  LOW  — выключена;
//   пин сегмента  LOW  — сегмент горит,      HIGH — не горит
//                 (с обеих сторон 3,3 В — разницы нет, ток не течёт).

void setup() {
  Serial.begin(115200);
  delay(200);
  Serial.printf("\n=== one_digit: показываю %d на %s цифре ===\n",
                DIGIT, POSITION == 1 ? "левой" : "правой");

  // Шаг 1. Все сегменты — выходы и выключены (HIGH)
  for (int i = 0; i < 7; i++) {
    pinMode(SEGMENT_PINS[i], OUTPUT);
    digitalWrite(SEGMENT_PINS[i], HIGH);
  }

  // Шаг 2. Обе цифры — выходы и выключены (LOW)
  pinMode(LEFT_DIGIT_PIN, OUTPUT);
  pinMode(RIGHT_DIGIT_PIN, OUTPUT);
  digitalWrite(LEFT_DIGIT_PIN, LOW);
  digitalWrite(RIGHT_DIGIT_PIN, LOW);

  // Шаг 3. Включаем нужные сегменты по таблице
  for (int i = 0; i < 7; i++) {
    if (DIGIT_SEGMENTS[DIGIT][i] == 1) {
      digitalWrite(SEGMENT_PINS[i], LOW);   // этот сегмент горит
      Serial.printf("  сегмент %s: горит   (GPIO %d = LOW)\n", SEGMENT_NAMES[i], SEGMENT_PINS[i]);
    } else {
      Serial.printf("  сегмент %s: —       (GPIO %d = HIGH)\n", SEGMENT_NAMES[i], SEGMENT_PINS[i]);
    }
  }

  // Шаг 4. Подаём «плюс» на выбранную цифру — она загорается
  int digitPin = (POSITION == 1) ? LEFT_DIGIT_PIN : RIGHT_DIGIT_PIN;
  digitalWrite(digitPin, HIGH);
  Serial.printf("  анод: GPIO %d = HIGH — цифра включена\n", digitPin);
}

void loop() {
  // Ничего не делаем: пины остаются в том состоянии, в каком их оставил setup(),
  // и цифра горит постоянно.
}
